# Keil uVision project auc_programmer.uvproj, settings and files
target auc_programmer (ARM-ADS)
  device: LPC11U14FHN33/201 NXP
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x1000) IRAM2(0x20004000,0x0800) CPUTYPE("Cortex-M0+") CLOCK(50000000) ELITTLE
  output: avalon-usb-converter
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  memory RVCT10: RAM 0x20004000 size 0x800
